# Autodesk Inventor assembly: 조립도
## iProperties
Created: 2014-11
Part Number: 조립도
Document SubType Name: Assembly
Designer: tw009
Author: tw009
